SUMMARY = "WPE bolt image"

require wpe-bolt-image-common.inc

IMAGE_INSTALL += "rdk-browserlauncher"
