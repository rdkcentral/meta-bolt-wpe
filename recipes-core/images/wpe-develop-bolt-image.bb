SUMMARY = "WPE bolt image with development tools"

require wpe-bolt-image-common.inc

IMAGE_INSTALL += "cog-launcher-develop"
