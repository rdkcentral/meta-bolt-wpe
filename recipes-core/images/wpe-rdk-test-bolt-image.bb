SUMMARY = "WPE bolt image with RDK Browser Launcher"

require wpe-bolt-image-common.inc

IMAGE_INSTALL += "rdk-browsertests"
