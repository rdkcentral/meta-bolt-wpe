SUMMARY = "Commercial licensed libraries pack"

inherit base-bolt-image

IMAGE_INSTALL += "gstreamer1.0-libav"
