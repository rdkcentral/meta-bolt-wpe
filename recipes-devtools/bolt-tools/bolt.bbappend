FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://licenses_workaround.patch;patchdir=.."
