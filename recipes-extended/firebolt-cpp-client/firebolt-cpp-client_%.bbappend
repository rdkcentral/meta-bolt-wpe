RDEPENDS:${PN}:remove = "firebolt-cpp-transport"
