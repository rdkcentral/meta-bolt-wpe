RDEPENDS:${PN}:remove = "websocketpp"
RDEPENDS:${PN}:remove = "boost-system"
