SRC_URI:remove = "file://0004-Make-graphic-libs-configurable_v1.5.9.patch"
